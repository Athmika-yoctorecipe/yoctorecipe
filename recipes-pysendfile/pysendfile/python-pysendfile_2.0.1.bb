require python-pysendfile.inc
inherit pypi setuptools
