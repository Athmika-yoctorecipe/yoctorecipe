require python-pyftpdlib.inc
inherit pypi setuptools
